# IAR project P24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RE ST STM32F205RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _PROJECT_IAR_; USE_STDPERIPH_DRIVER; VERSION_SECTION
  ICCARM.CCDiagSuppress: Pe826
  ICCARM.CCIncludePath2: HrdDrivers; ..\OS\mCOSII; ..\OS\OSConfig; ..\OS\OSport; Tsk; Func; DBG; ..\P24_vm; ; Main; ..\Font; STM32F2xx_StdPeriph_Lib_V1.1.0\Libraries\STM32F2xx_StdPeriph_Driver\inc\; STM32F2xx_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Device\ST\STM32F2xx\Include\; STM32F2xx_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Include\; STM32F2xx_StdPeriph_Lib_V1.1.0\; FOP_for_flash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: P24.bin
  ILINK.IlinkOutputFile: P24.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DBG
    DBG/: DbgTim.c TestScreen.c TIMMicro.c
  group FILE_FOR_MENU
    FOP_for_flash/: AT_24_prog_Pult_Mem.h
  group Font
    ../Font/: Font.c
  group FUNC
    Func/: Calc_New.c CRC.c CRC.h filemp.c filemp.h fixedUst.h Icon.c LevelMenu.c MakeOpis.c Manchester.c Menu.c MenuStatDrv.h MessageFlash.c MicroProg.c modbus.c Monitor.c SetupMenu.c TimeMy.c
  group HrdDrivers
    HrdDrivers/: dma.c Kbd.c LED.c Spi.c UART_manchester.c uc1698.c
    Func/: Triol.c
  group Lib
    STM32F2xx_StdPeriph_Lib_V1.1.0/Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    STM32F2xx_StdPeriph_Lib_V1.1.0/: stm32f2xx_it.c
  group Lib/CMSIS
    STM32F2xx_StdPeriph_Lib_V1.1.0/Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Lib/STM32F2xx_StdPeriph_Driver
    STM32F2xx_StdPeriph_Lib_V1.1.0/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Main
    Main/: initOSfile.c main.c OS_Obj.c SysTimers.c VersionPo.c
  group mCOSII
    ../OS/OSConfig/: os_dbg.c
    ../OS/mCOSII/: ucos_ii.c
  group OSport
    ../OS/OSport/: os_cpu_a.asm os_cpu_c.c
  group Screens
    Screens/: Screen1.c
  group TSK
    TSK/: TskControl.c TskDRV.c TskKbd.c TskLcd.c
